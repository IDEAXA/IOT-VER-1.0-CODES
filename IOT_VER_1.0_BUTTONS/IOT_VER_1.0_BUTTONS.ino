#include"iot_config.h"
#include <Wire.h> 
#include <LiquidCrystal_I2C.h> // install this library

LiquidCrystal_I2C lcd(0x27,16,2);
void setup()
{
  Serial.begin(9600);
  lcd.init();                 
  lcd.init();
  lcd.backlight(); 
  lcd.setCursor(0,0);
  lcd.print("IOT VER 1.0");
  delay(2000);
}
void loop()
{
lcd.setCursor(0,1);
lcd.print("PRESS BUTTONS");  
int data_in = analogRead(BUTTON_PIN);
  if(data_in < 5)
  {
    lcd.setCursor(0,0);
    lcd.print("BUTTON-1 PRESSED");
  }
  if(data_in > 900 && data_in < 1200)
  {
    lcd.setCursor(0,0);
    lcd.print("BUTTON-2 PRESSED");
  }
  if(data_in > 1500 && data_in < 2000)
  {
    lcd.setCursor(0,0);
    lcd.print("BUTTON-3 PRESSED");
  }
  if(data_in > 2200 && data_in < 2500)
  {
    lcd.setCursor(0,0);
    lcd.print("BUTTON-4 PRESSED");
  }
delay(100);
}
